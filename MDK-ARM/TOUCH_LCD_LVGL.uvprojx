# Keil uVision project TOUCH_LCD_LVGL.uvprojx, settings and files
target TOUCH_LCD_LVGL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TOUCH_LCD_LVGL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --diag_suppress=1,188
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../user_lvgl;../user_lvgl/lvgl;../user_lvgl/lvgl/src;../user_lvgl/lvgl/include/lvgl;../user_lvgl/lvgl/include/lvgl/config;../user_lvgl/lvgl/demos;../user_lvgl/lvgl/demos/stress;../user_lvgl/lvgl/User_ui;../user_lvgl/lvgl/User_ui/Button_scaling
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: TOUCH_LCD_LVGL\TOUCH_LCD_LVGL.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c dma2d.c fmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group My_Group
    ../Core/Src/: LCD.c delay.c touch.c
  group user_lvgl/lvgl/User_ui
    ../user_lvgl/lvgl/User_ui/: ui.c User_Operation_Screen.c User_Interface_Selection.c Settings.c Creator_WeChat.c Charging_Status.c Charging_Records.c Creator_WeChat_L.c
  group lv_config
    ../user_lvgl/: lv_conf.h
    ../user_lvgl/lvgl/src/: lv_init.c
  group lvgl/src/porting
    ../user_lvgl/lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl/src/core
    ../user_lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group lvgl/demos
    ../user_lvgl/lvgl/demos/stress/: lv_demo_stress.c
    ../user_lvgl/lvgl/demos/: lv_demos.c
  group lvgl/src/draw_display
    ../user_lvgl/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c
    ../user_lvgl/lvgl/src/display/: lv_display.c
    ../user_lvgl/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../user_lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../user_lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../user_lvgl/lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group lvgl/src/font
    ../user_lvgl/lvgl/src/font/: lv_font.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14_aligned.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../user_lvgl/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
  group lvgl/src/indev
    ../user_lvgl/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/src/misc
    ../user_lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../user_lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../user_lvgl/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../user_lvgl/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group lvgl/src/stdlib
    ../user_lvgl/lvgl/src/stdlib/: lv_mem.c
    ../user_lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../user_lvgl/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/tick
    ../user_lvgl/lvgl/src/tick/: lv_tick.c
  group lvgl/src/layout
    ../user_lvgl/lvgl/src/layouts/: lv_layout.c
    ../user_lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../user_lvgl/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/src/thems
    ../user_lvgl/lvgl/src/themes/: lv_theme.c
    ../user_lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../user_lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../user_lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgl/src/image
    ../user_lvgl/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../user_lvgl/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
  group lvgl/src/osal
    ../user_lvgl/lvgl/src/osal/: lv_os.c lv_os_none.c
  group lvgl/src/fs
    ../user_lvgl/lvgl/src/fs/: lv_fs.c
  group lvgl/src/debug
    ../user_lvgl/lvgl/src/debugging/sysmon/: lv_sysmon.c
  group user_lvgl/lvgl/src/widgets/animimage
    ../user_lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
  group user_lvgl/lvgl/src/widgets/arc
    ../user_lvgl/lvgl/src/widgets/arc/: lv_arc.c
  group user_lvgl/lvgl/src/widgets/arclabel
    ../user_lvgl/lvgl/src/widgets/arclabel/: lv_arclabel.c
  group user_lvgl/lvgl/src/widgets/bar
    ../user_lvgl/lvgl/src/widgets/bar/: lv_bar.c
  group user_lvgl/lvgl/src/widgets/barcode
    ../user_lvgl/lvgl/src/widgets/barcode/: lv_barcode.c
  group user_lvgl/lvgl/src/widgets/button
    ../user_lvgl/lvgl/src/widgets/button/: lv_button.c
  group user_lvgl/lvgl/src/widgets/buttonmatrix
    ../user_lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group user_lvgl/lvgl/src/widgets/calendar
    ../user_lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group user_lvgl/lvgl/src/widgets/canvas
    ../user_lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
  group user_lvgl/lvgl/src/widgets/chart
    ../user_lvgl/lvgl/src/widgets/chart/: lv_chart.c
  group user_lvgl/lvgl/src/widgets/checkbox
    ../user_lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group user_lvgl/lvgl/src/widgets/dropdown
    ../user_lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group user_lvgl/lvgl/src/widgets/ffmpeg
    ../user_lvgl/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
  group user_lvgl/lvgl/src/widgets/gif
    ../user_lvgl/lvgl/src/widgets/gif/: lv_gif.c
  group user_lvgl/lvgl/src/widgets/gstreamer
    ../user_lvgl/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
  group user_lvgl/lvgl/src/widgets/image
    ../user_lvgl/lvgl/src/widgets/image/: lv_image.c
  group user_lvgl/lvgl/src/widgets/imagebutton
    ../user_lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group user_lvgl/lvgl/src/widgets/ime
    ../user_lvgl/lvgl/src/widgets/ime/: lv_ime_pinyin.c
  group user_lvgl/lvgl/src/widgets/keyboard
    ../user_lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group user_lvgl/lvgl/src/widgets/label
    ../user_lvgl/lvgl/src/widgets/label/: lv_label.c
  group user_lvgl/lvgl/src/widgets/led
    ../user_lvgl/lvgl/src/widgets/led/: lv_led.c
  group user_lvgl/lvgl/src/widgets/line
    ../user_lvgl/lvgl/src/widgets/line/: lv_line.c
  group user_lvgl/lvgl/src/widgets/list
    ../user_lvgl/lvgl/src/widgets/list/: lv_list.c
  group user_lvgl/lvgl/src/widgets/lottie
    ../user_lvgl/lvgl/src/widgets/lottie/: lv_lottie.c
  group user_lvgl/lvgl/src/widgets/menu
    ../user_lvgl/lvgl/src/widgets/menu/: lv_menu.c
  group user_lvgl/lvgl/src/widgets/msgbox
    ../user_lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group user_lvgl/lvgl/src/widgets/objx_templ
    ../user_lvgl/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group user_lvgl/lvgl/src/widgets/property
    ../user_lvgl/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
  group user_lvgl/lvgl/src/widgets/qrcode
    ../user_lvgl/lvgl/src/widgets/qrcode/: lv_qrcode.c
  group user_lvgl/lvgl/src/widgets/roller
    ../user_lvgl/lvgl/src/widgets/roller/: lv_roller.c
  group user_lvgl/lvgl/src/widgets/scale
    ../user_lvgl/lvgl/src/widgets/scale/: lv_scale.c
  group user_lvgl/lvgl/src/widgets/slider
    ../user_lvgl/lvgl/src/widgets/slider/: lv_slider.c
  group user_lvgl/lvgl/src/widgets/span
    ../user_lvgl/lvgl/src/widgets/span/: lv_span.c
  group user_lvgl/lvgl/src/widgets/spinbox
    ../user_lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group user_lvgl/lvgl/src/widgets/spinner
    ../user_lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
  group user_lvgl/lvgl/src/widgets/switch
    ../user_lvgl/lvgl/src/widgets/switch/: lv_switch.c
  group user_lvgl/lvgl/src/widgets/table
    ../user_lvgl/lvgl/src/widgets/table/: lv_table.c
  group user_lvgl/lvgl/src/widgets/tabview
    ../user_lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
  group user_lvgl/lvgl/src/widgets/textarea
    ../user_lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
  group user_lvgl/lvgl/src/widgets/tileview
    ../user_lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
  group user_lvgl/lvgl/src/widgets/win
    ../user_lvgl/lvgl/src/widgets/win/: lv_win.c
software components: CMSIS:CORE 4.3.0
